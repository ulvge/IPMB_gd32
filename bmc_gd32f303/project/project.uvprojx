# Keil uVision project project.uvprojx, settings and files
target bmc_f207 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F207VC GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.2.3
  cpu: IROM(0x08000000,0x040000) IRAM(0x20000000,0x020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bmc_rom +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM3,__CC_ARM
  c include: ..\firmware\GD32F20x_standard_peripheral\Include;..\firmware\CMSIS\GD\GD32F20x\Include;..\firmware\CMSIS;..\user;..\bsp;..\ipmi;..\ipmi\data;..\ipmi\ipmi_dev-3.0.0-src\data;..\ipmi\ipmi_common;..\ipmi\libipmi-3.1.0-src\data\include;..\ipmb;..\api;..\freertos\include;..\freertos\portable\RVDS\ARM_CM3;..\lwip-2.0.2\port\GD32F20x;..\lwip-2.0.2\port\GD32F20x\FreeRTOS;..\lwip-2.0.2\src\include;..\api\net;..\api\shell;..\ff10;..\api\flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../user/: gd32f20x_it.c main.c systick.c
  group api
    ../api/adc/: api_adc.c
    ../api/fan/: api_fan.c
    ../api/pid/: pid.c
    ../api/tmp/: hwd1668.c api_tmp.c
    ../api/update/: flash.c update.c
    ../api/net_print/: net_print.c
    ../api/cpu/: api_cpu.c
    ../api/utc/: api_utc.c
    ../api/tools/: tools.c fatfs_tools.c
    ../api/flash/: api_flash.c
  group net
    ../api/net/: gd32f20x_enet_eval.c hello_gigadevice.c netconf.c tcp_client.c udp_echo.c
  group ipmi
    ../ipmi/ipmi_common/: ipmi_common.c
  group ipmb_msg_handlr
    ../ipmb/: IpmbMsgHndlr.c
    ../ipmb/libipmiserial-src/: SerialIfc.c Serial.c
    ../ipmb/libipmilan-src/: LANIfc.c RMCP.c
  group ipmi_msg_handlr
    ../ipmi/libipmimsghndlr-3.0.0-src/data/: MsgHndlr.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/App/: App.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/App/AppDevice/: AppDevice.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Chassis/: Chassis.c ChassisDevice.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Oem/: Oem.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/SensorEvent/: SensorEvent.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/SensorEvent/SensorDevice/: Sensor.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Storage/: Storage.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Storage/SDRDevice/: SDR.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/App/IPMDevice/: IPMDevice.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Bridge/: Bridge.c
  group libipmi
    ../ipmi/libipmi-3.1.0-src/data/: sensor_helpers.c
  group bsp
    ../bsp/: bsp_adc.c bsp_capture.c bsp_i2c.c bsp_i2c_gpio.c bsp_led.c bsp_pwm.c bsp_uart3.c bsp_uart7.c bsp_usart0.c bsp_usart1.c bsp_gpio.c bsp_net_gpio.c bsp_timer.c bsp_gd25qxx.c
  group cmsis
    ../firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group peripherals
    ../firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_cau.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exti.c gd32f20x_gpio.c gd32f20x_i2c.c gd32f20x_rcu.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_usart.c gd32f20x_wwdgt.c gd32f20x_misc.c gd32f20x_fmc.c gd32f20x_fwdgt.c
  group startup
    ../firmware/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group lwip
    ../lwip-2.0.2/port/GD32F20x/FreeRTOS/: ethernetif.c sys_arch.c
    ../lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.0.2/src/netif/: ethernet.c
  group shell
    ../api/shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group fatfs
    ../ff10/: diskio.c ff.c
    ../ff10/option/: cc936.c

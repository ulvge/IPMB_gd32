# Keil uVision project GD32F303Boot.uvprojx, settings and files
target F303Boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bmc_boot +hex
  AfterMake: "P:\4proj\8NS304 chaoYue\BMCproject\gd32\bmc_gd32f303\projectGD32F303Boot\output\autoMerge.bat"
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf --bin --output .\output\bmc_boot.bin .\output\temp\bmc_boot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM3,__CC_ARM,GD32F3x,BOOTLOADER
  c include: ..\firmware;..\firmware\GD32F30x\GD32F30x_standard_peripheral\Include;..\firmware\GD32F30x\CMSIS\GD\GD32F30x\Include;..\firmware\GD32F30x\CMSIS;..\user;..\bsp;..\ipmi;..\ipmi\data;..\ipmi\ipmi_dev-3.0.0-src;..\ipmi\ipmi_dev-3.0.0-src\data;..\ipmi\libipmi-3.1.0-src\data\include;..\ipmi\libipmi-3.1.0-src\data;..\ipmi\ipmi_common;..\ipmb;..\api;..\api\adc;..\api\flash;..\api\shell;..\api\tools;..\api\cpu;..\api\sensor;..\api\update;..\sub_devices;..\freertos\include;..\freertos\portable;..\freertos\portable\RVDS\ARM_CM4F;..\ff10;..\boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x17ff0
  memory RVCT10: RAM 0x20017ff0 size 0x10
  group app
    ../boot/: boot_main.c boot_update.c
    ../user/: systick.c
    ../firmware/GD32F30x/: gd32f30x_platform.c
    ../firmware/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_it.c
  group api
    ../api/tools/: FIFO.c FILO.c log.c
  group bsp
    ../api/update/: flash.c
    ../bsp/: bsp_timer.c bsp_uartcomm.c bsp_usart1.c
    ../boot/: boot_bsp_usart0.c
  group cmsis
    ../firmware/GD32F30x/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group peripherals
    ../firmware/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_dma.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_rtc.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c gd32f30x_dbg.c
  group startup
    ../firmware/GD32F30x/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c

# Keil uVision project GD32f303project.uvprojx, settings and files
target bmc_f303 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bmc_app +hex
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf --bin --output .\output\bmc_app.bin .\output\temp\bmc_app.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,__CC_ARM,GD32F3x
  c include: ..\firmware;..\firmware\GD32F30x\GD32F30x_standard_peripheral\Include;..\firmware\GD32F30x\CMSIS\GD\GD32F30x\Include;..\firmware\GD32F30x\CMSIS;..\user;..\bsp;..\ipmi;..\ipmi\data;..\ipmi\ipmi_dev-3.0.0-src;..\ipmi\ipmi_dev-3.0.0-src\data;..\ipmi\ipmi_common;..\ipmi\libipmi-3.1.0-src\data\include;..\ipmi\libipmi-3.1.0-src\data;..\ipmb;..\api;..\api\adc;..\api\flash;..\api\shell;..\api\tools;..\api\cpu;..\sub_devices;..\api\sensor;..\api\update;..\api\fan;..\freertos\include;..\freertos\portable;..\freertos\portable\RVDS\ARM_CM4F;..\ff10;..\api\cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ../api/update/: jump2Bootloader.c
    ../firmware/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_it.c
    ../user/: main.c systick.c
    ../firmware/GD32F30x/: gd32f30x_platform.c
  group sub_decives
    ../sub_devices/: api_subdevices.c dev_main.c dev_net.c dev_power.c dev_storage0.c dev_switch.c dev_fsm.c
  group api
    ../api/adc/: api_adc.c
    ../api/fan/: api_fan.c
    ../api/pid/: pid.c
    ../api/cpu/: api_cpu.c
    ../api/utc/: api_utc.c
    ../api/tools/: tools.c FIFO.c FILO.c cJSON.c log.c
    ../api/sensor/: api_sensor.c mac5023.c pmbus.c eeprom.c
  group ipmi
    ../ipmi/ipmi_common/: ipmi_common.c
  group ipmb_msg_handlr
    ../ipmb/: IpmbMsgHndlr.c
    ../ipmb/libipmiserial-src/: SerialIfc.c Serial.c
    ../ipmb/libipmilan-src/: RMCP.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/App/AppDevice/: ChassisCtrl.c
  group ipmi_msg_handlr
    ../ipmi/libipmimsghndlr-3.0.0-src/data/: MsgHndlr.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/App/: App.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/App/AppDevice/: AppDevice.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Chassis/: Chassis.c ChassisDevice.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Oem/: Oem.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/SensorEvent/: SensorEvent.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/SensorEvent/SensorDevice/: Sensor.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Storage/: Storage.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Storage/SDRDevice/: SDR.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/App/IPMDevice/: IPMDevice.c
    ../ipmi/libipmimsghndlr-3.0.0-src/data/Bridge/: Bridge.c
  group libipmi
    ../ipmi/libipmi-3.1.0-src/data/: sensor_helpers.c
  group bsp
    ../bsp/: bsp_adc.c bsp_capture.c bsp_i2c.c bsp_i2c_gpio.c bsp_led.c bsp_pwm.c bsp_uart3.c bsp_usart0.c bsp_usart1.c bsp_gpio.c bsp_net_gpio.c bsp_timer.c bsp_uartcomm.c
  group cmsis
    ../firmware/GD32F30x/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group peripherals
    ../firmware/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_dma.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_fwdgt.c gd32f30x_fmc.c gd32f30x_i2c.c gd32f30x_rtc.c gd32f30x_rcu.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_misc.c gd32f30x_usart.c gd32f30x_wwdgt.c gd32f30x_dbg.c
  group startup
    ../firmware/GD32F30x/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group shell
    ../api/shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group cm_backtrace
    ../api/cm_backtrace/: cm_backtrace.c cmb_fault.S

# Keil uVision project GD32F103Boot.uvprojx, settings and files
target F103Boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103VB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bmc_boot +hex
  AfterMake: "P:\4proj\8NS304 chaoYue\BMCproject\gd32\bmc_gd32f303\projectGD32F103Boot\output\autoMerge.bat"
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf --bin --output .\output\bmc_boot.bin .\output\temp\bmc_boot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM3,__CC_ARM,GD32F1x,BOOTLOADER
  c include: ..\firmware;..\firmware\GD32F10x\GD32F10x_standard_peripheral\Include;..\firmware\GD32F10x\CMSIS\GD\GD32F10x\Include;..\firmware\GD32F10x\CMSIS;..\user;..\bsp;..\ipmi;..\ipmi\data;..\ipmi\ipmi_dev-3.0.0-src;..\ipmi\ipmi_dev-3.0.0-src\data;..\ipmi\libipmi-3.1.0-src\data\include;..\ipmi\libipmi-3.1.0-src\data;..\ipmi\ipmi_common;..\ipmb;..\api;..\api\adc;..\api\flash;..\api\shell;..\api\tools;..\api\cpu;..\api\sensor;..\api\update;..\sub_devices;..\freertos\include;..\freertos\portable;..\freertos\portable\RVDS\ARM_CM3;..\ff10;..\boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4ff0
  memory RVCT10: RAM 0x20004ff0 size 0x10
  group app
    ../boot/: boot_main.c boot_update.c
    ../user/: systick.c
    ../firmware/GD32F10x/GD32F10x_standard_peripheral/Source/: gd32f10x_it.c
    ../firmware/GD32F10x/: gd32f10x_platform.c
  group api
    ../api/tools/: FIFO.c FILO.c log.c
  group bsp
    ../api/update/: flash.c
    ../bsp/: bsp_timer.c bsp_uartcomm.c bsp_usart1.c
    ../boot/: boot_bsp_usart0.c
  group cmsis
    ../firmware/GD32F10x/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group peripherals
    ../firmware/GD32F10x/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_dma.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c gd32f10x_dbg.c
  group startup
    ../firmware/GD32F10x/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
